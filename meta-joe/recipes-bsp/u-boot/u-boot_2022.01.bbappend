FILESEXTRAPATHS:append := ":${THISDIR}/files"
SRC_URI += " \
            file://custom.cfg \
            "